// Slip Attack — フルスケール・サーキットで「最速グリップ⇄リア流し」を切り替えて攻める  [競技 / フルスケール]  by Opus 4.8
// ★領域=フルスケール・レース / コース=競技サーキット (フルスケール) / 車=ドリフトFR★
//
// J3 の正直な前提(実測で確定):
//   ・このシムでは「ドリフト角を一定に保つ(保持ドリフト)」は前方ToFだけでは作れない。リアが流れ始めると
//     姿勢(ヨー/β)を読んで逆ハン(カウンター)を当てない限りスピン(β→180°)まで回り切ってしまう。
//   ・逆ハンには姿勢推定が要るが、ToF の時間変化からの姿勢推定は本シムでは不成立(Phase J1 = NO-GO)。
//   ・つまり「全周をドリフトのまま回る」「逆ハンでスピンを止める」は ToF×3 だけでは成立しない(走れば分かる)。
// だから本プログラムは "保持" を狙わず、実車の走法どおり【直線=最速グリップ / コーナー=リアを振って回頭】を
//   リズムで切り替える。コーナーではリアが流れて深く回頭し(=スピン側まで行く)、前が開けたらグリップで次へ進む。
//   姿勢は一切読まず、前方の詰まり(C)と左右差(L-R)だけで直線/コーナーを判断する。
//
// 補足(正直な実測): このスライドは開ループ(姿勢を読まない)では本質的に不安定で、コーナーごとに
//   β→180° まで回り切る「スピン→復帰」のリズムになる。サーキット半周ぶんは前進できるが、その先は
//   滑りが溜まってスタックしがち=全周ドリフトは成立しない。値を攻めるほど結果がブレる(決定論的カオス)
//   ので、ここは堅牢に半周前進できる素直な構成にしてある。
//
// 条件を変えて確かめよう(J4): この走りが成り立つのは「壁で囲まれたフルスケール・サーキット」。
//   プログラムはそのままで、領域やコースを変えて走らせると結果はどう変わる? 先回りの答えは書かない。
//   どんな条件なら成り立ち、どんな条件だと成り立たないかは、走った結果から自分で気づこう。
// ★Stage AO 注記(走行エンジン v2)★ v2(4輪 two-track・muXDrift ハック廃止・忠実な荷重移動)では、この実寸
//   フルスケール・コーナーは速度が高すぎて、コーナー進入で即スピンする(補足どおり「保持は不成立」が一層
//   はっきり出て、前進は最初の直線ぶんが主)。ToF×3+3値ステアでは姿勢を読めず逆ハンできない=スピンを
//   止められない限界(J1=NO-GO)は v2 でも不変。「最速安全」にはグリップ(弱アンダーFF)が有利で、ドリフトは
//   不利という物理が創発する。ドリフトの意味/利点を安全に学ぶには 卓上スリップタイヤ(Stage AO6)を参照。
int TOP, CORNER, BIAS, GUARD, GUARDS, DUTY, DUTYHI, FLARE, GRIP, CLOSE, BRK;
int CONF=150000;     // 信頼区間[mm]: >CONF/範囲外(-3)=「遠い/開放」。本フルスケールは実車レーダ相当の
// 150m レンジで設計しているので信頼区間もレーダ地平(150m)とする。実短距離 ToF の地面拘束は ~5m
// (=250mm×領域スケール20)ゆえ、実機/自機ではここを下げて要調整(下げるほど遠くの壁を見ず反応が遅れる)。
int prevC; int started; int t;

void setup() {
  RC_setup();
  TOP = 180; CORNER = 50000; BIAS = 6000; GUARD = 9000; GUARDS = 4500;
  DUTY = 24; DUTYHI = 9; FLARE = 210; GRIP = 150; CLOSE = 2200; BRK = 210;
  prevC = 0; started = 0; t = 0;
}

void loop() {
  int L = RC_read(LEFT);
  int C = RC_read(CENTER);
  int R = RC_read(RIGHT);
  if (L < 0 || L > CONF) L = 99000;   // 範囲外(-3) = 遠く開けている → 大きな値へ
  if (C < 0 || C > CONF) C = 99000;
  if (R < 0 || R > CONF) R = 99000;
  int dC = 0;
  if (started == 1) dC = prevC - C;   // dC>0 = 前方が縮む = 壁/コーナーへ接近
  prevC = C; started = 1; t = t + 1;

  // 壁ガード: 近すぎたら広い側へ舵を残してブレーキ(滑りの万能リセット)。前進で逃げない。
  if (C < GUARD || L < GUARDS || R < GUARDS) {
    if (L > R) RC_steer(LEFT); else RC_steer(RIGHT);
    RC_drive(BRAKE, 240);
    return;
  }

  // コーナー: 前方が詰まっている(C<CORNER)= 進入/旋回中。広い側(=内側・全周同じ向き)へ全舵を当て、
  //   スロットルを脈打たせて後輪を流す。逆ハンは当てない(姿勢が読めない=J1)のでリアは流れ切って回頭する。
  if (C < CORNER) {
    if (L >= R) RC_steer(LEFT); else RC_steer(RIGHT);
    if ((t % DUTY) < DUTYHI) RC_drive(FORWARD, FLARE);
    else RC_drive(FORWARD, GRIP);
    return;
  }

  // 直線: 中央寄せして最速グリップで踏む。前が速く詰まれば先読みブレーキでコーナーに備える。
  if (L - R > BIAS) RC_steer(LEFT);
  else if (R - L > BIAS) RC_steer(RIGHT);
  else RC_steer(CENTER);
  if (dC > CLOSE) RC_drive(BRAKE, BRK);
  else RC_drive(FORWARD, TOP);
}
